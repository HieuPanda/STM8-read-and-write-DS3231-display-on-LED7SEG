# IAR project stm8s_7LED_IC3231.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S005K6 STM8S005K6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: F:\STM8\STM8_LED7_3231; F:\STM8\STM8_LED7_3231\lib\delay; F:\STM8\STM8_LED7_3231\lib\sspi; F:\STM8\STM8_LED7_3231\lib\led7Seg; F:\STM8\STM8_LED7_3231\lib\i2c_soft; F:\STM8\STM8_LED7_3231\lib\i2c_soft\cfg; F:\STM8\STM8_LED7_3231\lib\IC_3231; F:\STM8\STM8_LED7_3231\lib\GPIO; F:\STM8\STM8_LED7_3231\lib\clock; F:\STM8\STM8_LED7_3231\lib\app
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: stm8s_7LED_IC3231.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
  group lib/app
    lib/app/: app.c app.h
  group lib/clock
    lib/clock/: clock.c clock.h
  group lib/delay
    lib/delay/: delay.c delay.h
  group lib/gpio
    lib/GPIO/: GPIO.c GPIO.h
  group lib/i2c_soft
    lib/i2c_soft/: i2c_soft.c i2c_soft.h
  group lib/i2c_soft/cfd
    lib/i2c_soft/cfg/: i2c_soft_cfg.c i2c_soft_cfg.h
  group lib/ic3231
    lib/IC_3231/: ic3231.c ic3231.h
  group lib/led7Seg
    lib/led7Seg/: led7Seg.c led7Seg.h
  group lib/sspi
    lib/sspi/: sspi.c sspi.h
